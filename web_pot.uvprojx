# Keil uVision project web_pot.uvprojx, settings and files
target XMC4500-F100x1024 (ARM-ADS)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: web_pot
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Thread_pump.c Thread_webserver.c logging_system.c HTTP_Server_CGI.c Thread_Sensors.c
  group Web
    ./Web/: graph.html index.html jquery.min.js.gz loc.cgx smoothie.js.gz web.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:RTE_Device 1.0.0, Device:Startup 1.0.0, Device:XMClib:CAN 1.0.0, Device:XMClib:CCU4 1.0.0, Device:XMClib:CCU8 1.0.0, Device:XMClib:DAC 1.0.0, Device:XMClib:DMA 1.0.0, Device:XMClib:EBU 1.0.0, Device:XMClib:ERU 1.0.0, Device:XMClib:FCE 1.0.0, Device:XMClib:FLASH 1.0.0, Device:XMClib:GPIO 1.0.0, Device:XMClib:HRPWM 1.0.0, Device:XMClib:I2C 1.0.0, Device:XMClib:LEDTS 1.0.0, Device:XMClib:POSIF 1.0.0, Device:XMClib:RTC 1.0.0, Device:XMClib:SCU 1.0.0, Device:XMClib:SDMMC 1.0.0, Device:XMClib:SPI 1.0.0, Device:XMClib:UART 1.0.0, Device:XMClib:USB 1.0.0, Device:XMClib:VADC 1.0.0, Device:XMClib:WDT 1.0.0
